require orc.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "72e0612ace54d77aa2f7a006348ee81a"
SRC_URI[sha256sum] = "767eaebce2941737b43368225ec54598b3055ca78b4dc50c4092f5fcdc0bdfe7"
